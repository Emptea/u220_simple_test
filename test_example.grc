options:
  parameters:
    generate_options: qt_gui
    id: test_example
    output_language: python
    title: lab3_antsdr_tone
  states: {}

blocks:
- name: amp_0
  id: variable_qtgui_range
  parameters:
    label: Amplitude0
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: amp_1
  id: variable_qtgui_range
  parameters:
    label: Amplitude1
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: bw
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 3.6e9
  states: {}
- name: duty
  id: variable
  parameters:
    value: 40/232
  states: {}
- name: freq_0
  id: variable_qtgui_range
  parameters:
    label: Frequency0
    start: '0'
    step: '50'
    stop: 2e9
    value: 100e3
  states: {state: disabled}
- name: freq_1
  id: variable_qtgui_range
  parameters:
    label: Frequency1
    start: '0'
    step: '50'
    stop: 5e6
    value: 625e3
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: train_freq
  id: variable
  parameters:
    value: samp_rate/232
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '6.2832'
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_0
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ''
    type: float
    vector: '[1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,1 ,1 ,1 ,1 ,1 ,1 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_ rx1"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_rx2"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_rx2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_rx1"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: re
    label2: im
    name: '"Generated signal"'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: re
    name: '"Generated signal"'
    size: '232'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 1e6
    bw1: 1e6
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_sig_source_x_1, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '1']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
