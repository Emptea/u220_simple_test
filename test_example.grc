options:
  parameters:
    generate_options: qt_gui
    id: test_example
    output_language: python
    title: lab3_antsdr_tone
  states: {}

blocks:
- name: amp_0
  id: variable_qtgui_range
  parameters:
    label: Amplitude0
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: amp_1
  id: variable_qtgui_range
  parameters:
    label: Amplitude1
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 3.6e9
  states: {}
- name: freq_0
  id: variable_qtgui_range
  parameters:
    label: Frequency0
    start: '0'
    step: '50'
    stop: 2e9
    value: 10e3
  states: {}
- name: freq_1
  id: variable_qtgui_range
  parameters:
    label: Frequency1
    start: '0'
    step: '50'
    stop: 500e3
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_0
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_0
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_1
    freq: freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: amp_1
    freq: freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_ch0"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_ch1"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_ch1"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_ch0"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 1e6
    bw1: 1e6
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
