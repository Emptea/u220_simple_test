options:
  parameters:
    generate_options: qt_gui
    id: test_example
    output_language: python
    title: lab3_antsdr_tone
  states: {}

blocks:
- name: amp_0
  id: variable_qtgui_range
  parameters:
    label: Amplitude0
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: amp_1
  id: variable_qtgui_range
  parameters:
    label: Amplitude1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: bw
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 3.6e9
  states: {}
- name: duty
  id: variable
  parameters:
    value: 40/232
  states: {}
- name: freq_0
  id: variable_qtgui_range
  parameters:
    label: Frequency0
    orient: Qt.Horizontal
    start: '0'
    step: '50'
    stop: 2e9
    value: 100e3
  states: {state: disabled}
- name: freq_1
  id: variable_qtgui_range
  parameters:
    label: Frequency1
    orient: Qt.Horizontal
    start: '0'
    step: '50'
    stop: 5e6
    value: 625e3
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: train_freq
  id: variable
  parameters:
    value: samp_rate/232
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '6.2832'
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_0
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx1_signal.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: rx2_signal.bin
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ''
    type: float
    vector: '[1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,1 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,1 ,1 ,1 ,1 ,1 ,1 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ''
    type: complex
    vector: '[1 , 0.996917333733128 + 0.0784590957278449j,  0.951056516295154 + 0.309016994374947j,  0.760405965600031 + 0.649448048330184j,  0.309016994374947 + 0.951056516295154j,  -0.382683432365090 + 0.923879532511287j,  -0.951056516295154 + 0.309016994374948j,  -0.760405965600031 - 0.649448048330184j,  0.309016994374947 - 0.951056516295154j,  0.996917333733128 + 0.0784590957278451j,  3.06161699786838e-16 + 1.00000000000000j,  -0.996917333733128 - 0.0784590957278450j,  0.309016994374947 - 0.951056516295154j,  0.760405965600031 + 0.649448048330184j,  -0.951056516295153 + 0.309016994374948j,  0.382683432365090 - 0.923879532511287j,  0.309016994374948 + 0.951056516295153j,  -0.760405965600031 - 0.649448048330183j,  0.951056516295153 + 0.309016994374948j,  -0.996917333733128 - 0.0784590957278443j,  1.00000000000000 - 1.22464679914735e-15j,  -0.996917333733128 - 0.0784590957278440j,  0.951056516295154 + 0.309016994374948j,  -0.760405965600034 - 0.649448048330180j,  0.309016994374949 + 0.951056516295153j,  0.382683432365085 - 0.923879532511289j,  -0.951056516295154 + 0.309016994374948j,  0.760405965600032 + 0.649448048330182j,  0.309016994374945 - 0.951056516295154j,  -0.996917333733128 - 0.0784590957278428j,  9.79098458681294e-16 + 1.00000000000000j,  0.996917333733128 + 0.0784590957278389j,  0.309016994374944 - 0.951056516295155j,  -0.760405965600035 - 0.649448048330179j,  -0.951056516295153 + 0.309016994374949j,  -0.382683432365087 + 0.923879532511288j,  0.309016994374944 + 0.951056516295155j,  0.760405965600038 + 0.649448048330175j,  0.951056516295154 + 0.309016994374945j,  0.996917333733128 + 0.0784590957278443j, 0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0.866025403784439 + 0.500000000000000j,  -0.500000000000000 + 0.866025403784439j,  -1.83697019872103e-16 - 1.00000000000000j,  -0.499999999999999 + 0.866025403784439j,  0.866025403784439 + 0.499999999999999j, 0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0 ,0,0]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_ rx1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: '"spectrum_rx2"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_rx2"'
    size: '232'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"scope_rx1"'
    size: '232'
    srate: samp_rate
    tr_chan: '1'
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: re
    label2: im
    name: '"Generated signal"'
    size: '232'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    dev_args: '"recv_frame_size=16384,num_recv_frames=512, send_frame_size=16384,num_send_frames=512"'
    gain0: gain
    gain1: gain
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 1e6
    bw1: 1e6
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"type=b200"'
    dev_args: '"recv_frame_size=16384,num_recv_frames=512, send_frame_size=16384,num_send_frames=512"'
    gain0: '40'
    gain1: '40'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_sig_source_x_1, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '1']
- [blocks_vector_source_x_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_source_x_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_source_x_0_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
